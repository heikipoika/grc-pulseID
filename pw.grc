<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>900000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>100</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sample_and_hold_xx</key>
<param><key>id</key><value>blocks_sample_and_hold_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.1</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.05</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0</value></param>
<param><key>high</key><value>0.1</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.05</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1</value></param>
<param><key>high</key><value>0.1</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.05</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>chan</key><value>1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import sys
import pmt
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, chan=1):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='counter',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.example_param = 0
        self.prev = 0
        self.chan = chan
        self.message_port_register_out(pmt.intern('msg_out'))

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        if np.any(input_items[0][:] &gt; 0):
            for i in range (1, len(input_items[0])):
                if (self.prev == 0) and (input_items[0][i] == 1):
                    self.example_param = 1
                if (self.prev == 1):
                    self.example_param = self.example_param + 1
                if (self.prev == 1 and input_items[0][i] == 0):
                    sys.stdout.write("%i: %i \n" % (self.chan, self.example_param))
                    self.message_port_pub(pmt.intern('msg_out'), pmt.from_long(self.chan))
                self.prev = input_items[0][i]
            
        #output_items[0][:] = self.example_param
        return len(input_items[0])
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_0</value></param>
<param><key>chan</key><value>2</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import sys
import pmt
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, chan=1):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='counter',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.example_param = 0
        self.prev = 0
        self.chan = chan

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        if np.any(input_items[0][:] &gt; 0):
            for i in range (1, len(input_items[0])):
                if (self.prev == 0) and (input_items[0][i] == 1):
                    self.example_param = 1
                if (self.prev == 1):
                    self.example_param = self.example_param + 1
                if (self.prev == 1 and input_items[0][i] == 0):
                    sys.stdout.write("%i: %i \n" % (self.chan, self.example_param))
                self.prev = input_items[0][i]
            
        #output_items[0][:] = self.example_param
        return len(input_items[0])
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0_0_0</value></param>
<param><key>chan</key><value>3</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
import sys
import pmt
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, chan=1):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='counter',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.example_param = 0
        self.prev = 0
        self.chan = chan

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        if np.any(input_items[0][:] &gt; 0):
            for i in range (1, len(input_items[0])):
                if (self.prev == 0) and (input_items[0][i] == 1):
                    self.example_param = 1
                if (self.prev == 1):
                    self.example_param = self.example_param + 1
                if (self.prev == 1 and input_items[0][i] == 0):
                    sys.stdout.write("%i: %i \n" % (self.chan, self.example_param))
                self.prev = input_items[0][i]
            
        #output_items[0][:] = self.example_param
        return len(input_items[0])
</value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf_0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>ch_map</key><value>[]</value></param>
<param><key>nchans</key><value>3</value></param>
<param><key>osr</key><value>1.0</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value>ip:pluto.local</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>433920000</value></param>
<param><key>manual_gain</key><value>64.0</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>20000000</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>300</value></param>
<param><key>min</key><value>-300</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_1</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0_0</source_block_id><sink_block_id>epy_block_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0_1</source_block_id><sink_block_id>epy_block_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sample_and_hold_xx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0</source_block_id><sink_block_id>blocks_float_to_char_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1</source_block_id><sink_block_id>blocks_float_to_char_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>msg_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
